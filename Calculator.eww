<workspace>
  <project>
    <path>Calculator.ewp</path>
    <name>Calculator</name>
  </project>
</workspace>
