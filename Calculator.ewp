# IAR project Calculator.ewp, settings and files
configuration Debug (ARM)
  group Source Files
    ./: calculator.c
